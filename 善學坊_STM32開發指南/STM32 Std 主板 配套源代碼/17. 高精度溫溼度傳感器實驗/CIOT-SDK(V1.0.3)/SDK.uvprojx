# Keil uVision project SDK.uvprojx, settings and files
target Builder (6180000::V6.18::ARMCLANG)
  device: STM32F030F4Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM32F030 +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3
  c define: USE_STDPERIPH_DRIVER,STM32F030,HAL_BUTTON_USE_IRQ,__SOFTFP__=1
  c include: .\Libraries\CMSIS\Include;.\Libraries\CMSIS\Device\ST\STM32F0xx\Include;.\Libraries\STM32F0xx_StdPeriph_Driver\inc;.\Userspace
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Startup
    ./Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f030.s
  group CMSIS
    ./Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group FWLIB
    ./Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_exti.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_dma.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_usart.c stm32f0xx_tim.c
  group Userspace
    ./Userspace/: stm32f0xx_it.c hal_adc.c hal_button.c hal_lcd_spi.c hal_led.c hal_oled12864.c hal_spi.c hal_system.c hal_timer.c hal_uart.c hal_dht20.c svc_task.c svc_log.c svc_plugins.c svc_button.c svc_sensor.c task_test.c task_led.c task_uart.c task_lcd.c task_input.c task_sensor.c main.c
