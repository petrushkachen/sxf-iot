# Keil uVision project Project.uvprojx, settings and files
target STM32F030 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F030C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM32F030 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F030,HAL_BUTTON_USE_IRQ
  c misc: --C99
  c include: ..\;..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F0xx\Include;..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\Libraries\STM32F0xx_CPAL_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
    ../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f030.s
  group User
    ../: main.c stm32f0xx_it.c hal_system.c hal_led.c hal_button.c hal_timer.c hal_uart.c hal_adc.c hal_spi.c hal_oled12864.c hal_lcd_spi.c
  group StdPeriph_Driver
    ../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_misc.c stm32f0xx_tim.c stm32f0xx_exti.c stm32f0xx_usart.c stm32f0xx_adc.c stm32f0xx_spi.c
